# IAR project SimpleBLEPeripheral.ewp, settings and files
configuration CC2541 (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2541F256.i51
  ICC8051.CCDefines: INT_HEAP_LEN=1000; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; POWER_SAVING; xPLUS_BROADCASTER; HAL_LCD=FALSE; HAL_LED=FALSE; HAL_UART=FALSE; LCD_TO_UART
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\..\common; ..\..\include; ..\..\..\..\Components\hal\include; ..\..\..\..\Components\hal\target\CC2540EB; ..\..\..\..\Components\osal\include; ..\..\..\..\Components\services\saddr; ..\..\..\..\Components\ble\include; ..\..\..\..\Components\ble\controller\phy; ..\..\..\..\Components\ble\controller\include; ..\..\..\..\Components\ble\hci; ..\..\..\..\Components\ble\host; ..\..\common\cc2540; ..\..\common\npi\npi_np; ..\..\Profiles\Roles; ..\..\Profiles\SimpleProfile; ..\..\Profiles\DevInfo; ..\..\Profiles\OAD
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  XLINK.XclFile: ..\..\common\cc2540\ti_51ew_cc2540b.xcl
configuration CC2541_SBL (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: INT_HEAP_LEN=1000; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; POWER_SAVING; xPLUS_BROADCASTER; HAL_LCD=FALSE; HAL_LED=FALSE; HAL_UART=FALSE; xLCD_TO_UART; MAKE_CRC_SHDW; FEATURE_SBL; OAD_KEEP_NV_PAGES
  ICC8051.CCIncludePath2: ..\..\common; ..\..\include; ..\..\..\..\Components\hal\include; ..\..\..\..\Components\hal\target\CC2540EB; ..\..\..\..\Components\osal\include; ..\..\..\..\Components\services\saddr; ..\..\..\..\Components\ble\include; ..\..\..\..\Components\ble\controller\phy; ..\..\..\..\Components\ble\controller\include; ..\..\..\..\Components\ble\hci; ..\..\..\..\Components\ble\host; ..\..\common\cc2540; ..\..\common\npi\npi_np; ..\..\Profiles\Roles; ..\..\Profiles\SimpleProfile; ..\..\Profiles\DevInfo; ..\..\Profiles\OAD; C:\Users\Administrator\Desktop\hardware\test4_a1\BLE_NEW\BLE_NEW\Projects\ble\common\cc2540
  postbuild: "..\..\common\cc2540\cc254x_ubl_pp.bat" "$PROJ_DIR$" "ProdUBL" "CC2541_SBL\Exe\SimpleBLEPeripheral"
  XLINK.XclFile: C:\Users\Administrator\Desktop\hardware\test5_a1\NEW\BLE_NEW\Projects\ble\common\cc2540\cc254x_f256_sbl.xcl
  group APP
    ../Source/: AT020.h at080.c buffer.c buffer.h dsp_finger.c dsp_finger.h hal_i2c.c hal_i2c.h hal_sensor.c hal_sensor.h iic.c iic.h moni121.c MPR121.c MPR121.h OSAL_SimpleBLEPeripheral.c PN532.c PN532.h simpleBLEPeripheral.c simpleBLEPeripheral.h SimpleBLEPeripheral_Main.c
    ../../../../../../Lock_BLE/BLE-CC254x-1.3.2/Projects/ble/Profiles/OAD/: oad.h
  group HAL/Common
    ../../../../Components/hal/common/: hal_drivers.c
  group HAL/Include
    ../../../../Components/hal/include/: hal_adc.h hal_assert.h hal_board.h hal_defs.h hal_drivers.h hal_flash.h hal_key.h hal_lcd.h hal_led.h hal_rpc.h hal_sleep.h hal_timer.h hal_uart.h
    ../../../../Components/services/saddr/: saddr.h
  group HAL/Target/CC2540EB/Config
    ../../../../Components/hal/target/CC2540EB/: hal_board_cfg.h
  group HAL/Target/CC2540EB/Drivers
    ../../../../Components/hal/target/CC2540EB/: hal_adc.c hal_aes.c hal_crc.c hal_dma.c hal_flash.c hal_key.c hal_lcd.c hal_led.c hal_sleep.c hal_startup.c hal_timer.c hal_uart.c
  group HAL/Target/CC2540EB/Includes
    ../../../../Components/hal/target/CC2540EB/: hal_aes.h hal_ccm.h hal_crc.h hal_dma.h hal_mcu.h hal_types.h
  group HAL/Target/CC2541ST
    ../../../../Components/hal/target/CC2541ST/: hal_acc.c hal_acc.h hal_aes.c hal_aes.h hal_assert.c hal_bar.c hal_bar.h hal_board_cfg.h hal_crc.c hal_crc.h hal_dma.c hal_dma.h hal_flash.c hal_gyro.c hal_gyro.h hal_humi.c hal_humi.h hal_i2c.c hal_i2c.h hal_interrupt.c hal_irtemp.c hal_irtemp.h hal_keys.c hal_keys.h hal_led.c hal_mag.c hal_mag.h hal_mcu.h hal_sensor.c hal_sensor.h hal_sleep.c hal_startup.c hal_timer.c hal_types.h
  group INCLUDE
    ../../../../Components/ble/include/: att.h gap.h gatt.h gatt_uuid.h hci.h l2cap.h sm.h
    ../../../../Components/ble/host/: linkdb.h
    ../../../../Components/ble/controller/include/: ll.h phy.h
    ../../common/npi/npi_np/: npi.h
  group LIB
    ../../Libraries/CC2541DB/bin/: CC2541_BLE_peri.lib
    ../../Libraries/Common/bin/: CC254x_BLE_HCI_TL_None.lib
  group NPI
    ../../common/npi/npi_np/: npi.c
  group OSAL
    ../../../../Components/ble/include/: bcomdef.h
    ../../../../Components/osal/common/: OSAL.c osal_bufmgr.c osal_cbtimer.c OSAL_ClockBLE.c OSAL_Memory.c OSAL_PwrMgr.c OSAL_Timers.c
    ../../../../Components/osal/mcu/cc2540/: osal_snv.c
  group PROFILES
    ../../Profiles/DevInfo/: devinfoservice.c devinfoservice.h
    ../../Profiles/Roles/: gap.c gapbondmgr.c gapbondmgr.h peripheral.c peripheral.h peripheralBroadcaster.c peripheralBroadcaster.h
    ../../Include/: gapgattserver.h gattservapp.h
    ../../../../Components/ble/host/: gatt_uuid.c
    ../../Profiles/OAD/: oad.h oad_target.c oad_target.h
    ../../Profiles/SimpleProfile/: simpleGATTprofile.c simpleGATTprofile.h
    ../../Profiles/Keys/: simplekeys.c simplekeys.h
  group TOOLS
    ../../config/: buildComponents.cfg
    ./: buildConfig.cfg
    ../../common/cc2540/: OnBoard.c OnBoard.h
